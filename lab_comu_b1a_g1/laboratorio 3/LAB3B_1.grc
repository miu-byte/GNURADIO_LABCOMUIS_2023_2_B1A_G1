options:
  parameters:
    author: labcom_B1A_G1
    description: LAB3_B_1
    generate_options: qt_gui
    id: LAB3B_1
    output_language: python
    title: TransmisorAM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '100e-3'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    start: '0'
    step: '100e-6'
    stop: '4'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm1
  id: variable_qtgui_range
  parameters:
    label: frec m1
    start: '0'
    step: '10'
    stop: '10000'
    value: '1000'
  states: {}
- name: fm2
  id: variable_qtgui_range
  parameters:
    label: frec m2
    start: '0'
    step: '100'
    stop: '10000'
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: LAB3_parteB_0
  id: LAB3_parteB
  parameters:
    Ac: Ac
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [LAB3_parteB_0, '0', qtgui_freq_sink_x_0, '0']
- [LAB3_parteB_0, '0', qtgui_time_sink_x_0, '0']
- [LAB3_parteB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', LAB3_parteB_0, '0']
- [analog_sig_source_x_0_0, '0', LAB3_parteB_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
