options:
  parameters:
    author: labcom_B1A_g1
    category: '[MODULOS B1A G1]'
    copyright: labcom_B1A_g1
    description: lab3_5
    generate_options: hb
    id: MODULADOR_SSB_LAB3_5
    output_language: python
    title: MODULADOR SSB
  states: {}

blocks:
- name: Ac
  id: parameter
  parameters:
    label: Amplitud portadora
    type: eng_float
    value: '1'
  states: {}
- name: B
  id: parameter
  parameters:
    label: Cambio de banda
    type: eng_float
    value: '1'
  states: {}
- name: K
  id: parameter
  parameters:
    label: Habilita portadora
    type: eng_float
    value: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: K
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: B
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '257'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: m(t)
    type: float
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_1, '0', pad_sink_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']
- [pad_source_0, '0', hilbert_fc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
