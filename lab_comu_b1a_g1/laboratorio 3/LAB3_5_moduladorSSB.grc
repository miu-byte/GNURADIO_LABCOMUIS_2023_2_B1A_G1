options:
  parameters:
    author: labcom_b1a_g1
    description: lab3_5
    generate_options: qt_gui
    id: ModuladorAmplitud
    output_language: python
    title: Modulador Amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud Mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de Banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: '1000'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia Transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: Habilita portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5625e6
  states: {}
- name: Calculopotenciacomunicaciones_0
  id: Calculopotenciacomunicaciones
  parameters:
    I_Vect: '1024'
  states: {}
- name: MODULADOR_SSB_LAB3_5_0
  id: MODULADOR_SSB_LAB3_5
  parameters:
    Ac: Ac
    B: B
    K: K
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [MODULADOR_SSB_LAB3_5_0, '0', qtgui_freq_sink_x_0, '0']
- [MODULADOR_SSB_LAB3_5_0, '0', qtgui_time_sink_x_0, '0']
- [MODULADOR_SSB_LAB3_5_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Calculopotenciacomunicaciones_0, '0']
- [analog_sig_source_x_0, '0', MODULADOR_SSB_LAB3_5_0, '0']
- [blocks_complex_to_real_0, '0', Calculopotenciacomunicaciones_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
