options:
  parameters:
    author: B1A G1
    copyright: B1A G1
    description: Modulacion PM B1A G1
    generate_options: qt_gui
    id: ModulacionPM
    output_language: python
    title: Modulacion PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud Portadora '
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud Mensaje
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia Transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: 50e6
    step: 1e6
    stop: 2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del Mensaje
    start: 1e3
    step: '100'
    stop: 20e3
    value: 1e3
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente kp
    start: '0'
    step: '1e-6'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6.25e6
  states: {}
- name: Envolvente_compleja_0
  id: Envolvente_compleja
  parameters:
    Ac: Ac
    kp: kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_compleja_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_compleja_0, '0', qtgui_time_sink_x_0, '0']
- [Envolvente_compleja_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_compleja_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
